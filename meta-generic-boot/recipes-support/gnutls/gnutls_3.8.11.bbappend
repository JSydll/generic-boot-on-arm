# Required to build EFI capsules (with PKCS11 support)
PACKAGECONFIG:append:class-native = " p11-kit"
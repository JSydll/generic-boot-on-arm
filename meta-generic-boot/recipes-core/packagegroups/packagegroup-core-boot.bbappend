RDEPENDS:${PN}:remove = "grub-efi"